# Repository Hocus-Pocus/Buggly-Gruesome

File README.md:

# Buggly-Gruesome 
This is a stripped down, no frills version of the MSnS extra 029y4a
 code designed to run a stock or nearly stock 4cyl air cooled VW engine
 with Mexican EFI hardware. It uses a modified Megasquirt V2.2 board and a
 custom relay board and is tuned with Tuner Studio running the 029y4a
 .ini file.
 Text editor is Notepad++. Developement suite is Winide.exe. Firmware is
 loaded with prog08sz.exe and the Megaprogrammer by Patrick Carlier.
 It is absolutely essential that the controller is able to communicate
 with and be tuned with Tuner Studio, so the mainController.ini file has
 not been modified. Other than a cosmetic tidy up the msns-extra.h file
 has not been modified. In order to stay compatible with Tuner Studio all
 the variables and configurable constants have been left in place even
 though only a small fraction of them are actually used.
 The engine uses a degreed crank pully and a 36 minus 1 tooth trigger
 wheel with a VR sensor from CB Performance. The sensor conditioner is in
 the relay board with the coil drivers. Fuel strategy is speed density.
 Ignition is waste spark and injection is sequential paired. Pulse widths
start at 10 degrees ATDC and 10 degrees ABDC. Half the fuel delivered on
an open intake valve and the other half on a closed intake valve. Idle
control is PWM for warmup only. I do not use closed loop AFR control or
decel fuel cut, but the options are still there.

## KiCad design KiCad files/Buggly Gruesome Aux.kicad_pcb

Parts:
D1: ECU; LED_D5.0mm
D2: Tach; LED_D5.0mm
D3: INJ1; LED_D5.0mm
D4: INJ2; LED_D5.0mm
D5: CoilA; LED_D5.0mm
D6: CoilB; LED_D5.0mm
D7: FP; LED_D5.0mm
D8: IAC; LED_D5.0mm
D9: EGO; LED_D5.0mm
F1, F4: RXEF110; Fuse_Bourns_MF-RHT650
F2: RXEF135-1; Fuse_Bourns_MF-RHT750
F3: 20A; 01530008Z_Fuse_Holder
F5, F6, F7: 10A; 01530008Z_Fuse_Holder
F8, F9: 5A; 01530008Z_Fuse_Holder
HS1, HS2: Heatsink_Pad_2Pin; ISL9V3040P3_Heat_Sink
J1: DB25_Female; DSUB-25_Female_Horizontal_P2.77x2.84mm_EdgePinOffset9.90mm_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
J2, J3: 277-1245-ND; Phoenix_1729102
J4: 277-1270-ND; Phoenix_1714968
K1: Main; Panasonic_CM1-R-12V
K2: Automatic Shut Down; Panasonic_CM1-R-12V
Q1: BC33725BU; TO-92-3_Formed_Leads
Q2, Q3: ISL9V3040P3; TO-220-3_Vertical_Wide
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R12: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: Single_VR_Signal_Conditioner; Single_VR_Conditioner

Connections:
5Vlt: F1.2, J2.11, U1.5
12VoltSwitched: J4.2, K1.86
12VoltUnswitched: F3.2, J4.1
ASD: J1.13, K2.85
CLT: J1.14, J2.2
CoilA: D5.1 (K), J3.10, Q2.2 (C)
CoilB: D6.1 (K), J3.11, Q3.2 (C)
Coils+: F6.2, J3.9, R7.1, R8.1
ECU: F2.1, J1.24, R1.1
EGO+: F9.2, J3.8, R11.1
EGO-: D1.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), HS1.1, HS1.2, HS2.1, HS2.2, J1.7, J1.8, J1.10, J1.11, J1.19, J1.20, J1.23, J3.1, J3.7, J4.3, K1.85, Q1.3 (E), Q2.3 (E), Q3.3 (E), R12.1, U1.2
FlPmp: F7.2, J3.5, R9.1
Idle+: F8.2, J3.6, R10.1
Idle-: J1.4, J2.7
Inj1-: D3.1 (K), J1.5, J1.17, J2.8
Inj2-: D4.1 (K), J1.6, J1.18, J2.9
Injs+: F5.2, J2.10, R5.1, R6.1
MAT: J1.1, J2.1
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R4.2
unnamed: D3.2 (A), R5.2
unnamed: D4.2 (A), R6.2
unnamed: D5.2 (A), R7.2
unnamed: D6.2 (A), R8.2
unnamed: D7.2 (A), R9.2
unnamed: D8.2 (A), R10.2
unnamed: D9.2 (A), R11.2
unnamed: F1.1, J1.12
unnamed: F2.2, K1.87, K2.30, K2.86
unnamed: F3.1, K1.30
unnamed: F4.1, F5.1, F6.1, F7.1, F8.1, F9.1, K2.87
unnamed: F4.2, R3.1, R4.1
unnamed: Q1.2 (B), R2.1, R12.2
O2: J1.2, J2.3
SigRtn: J1.3, J1.16, J2.5, J2.6
SpkA: J1.9, Q2.1 (G)
SpkB: J1.21, Q3.1 (G)
TPS: J1.15, J2.4
Tach: D2.1 (K), J3.4, Q1.1 (C), R3.2
TachOut: J1.22, R2.2
VR+: J3.3, U1.3
VR-: J3.2, U1.1
VRout: J1.25, U1.7

Notes on the sheet:
IGBT
YlGn
DpRd
10 Amp Rated
30 Amp Rated
Note! Flyback diodes are an addition and not part of the board

Board: 2 copper layers, 152.0 x 99.0 mm, 42 parts (0 on the bottom side), 43 nets.

## Commit log

2022-11-16 Create Git Hold
